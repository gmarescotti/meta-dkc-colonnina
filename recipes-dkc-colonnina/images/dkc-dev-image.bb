DESCRIPTION = "DKC Develop Image"
LICENSE = "MIT"

require recipes-atmel/images/microchip-headless-image.bb

